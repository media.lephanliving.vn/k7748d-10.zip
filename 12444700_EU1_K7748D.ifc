Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: fe5790ef-cc5b-43eb-91ef-1e8c74368b11, NumberOfSaves: 1]
File name: 0001
Time: 2024-03-28T09:54:36+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12444700_EU1_K7748D:36774804_EU1_12444700_K7748D, (2)
In: Default
Type - Material: z_Miele_Design_Zinc_Steel, z_Miele_Design_BRWS, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, <Unnamed>, z_Miele_Design_Glass, z_Miele_Connection_Electric
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 36774804_EU1_12444700_K7748D; sets with these values: 2

# IfcDistributionPort, Port_354281_1
Description: Flow; FlowDirection: SOURCEANDSINK
